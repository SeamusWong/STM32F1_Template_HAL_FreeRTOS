# Keil uVision project SeamusWong（WHX）HAL_FreeRTOS.uvprojx, settings and files
target SeamusWong（WHX）HAL_FreeRTOS (6190000::V6.19::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=4
  c define: USE_HAL_DRIVER,STM32F103xE,USE_STDPERIPH_DRIVER
  c include: .\FreeRTOS\Port\GCC\ARM_CM3;.\FreeRTOS\Include;.\Libraries\CMSIS\Device\Include;.\Libraries\CMSIS\Include;.\HAL\Inc;.\FatFs;.\User\;.\User\bsp\Include;.\User\whx_libraries\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUp
    ./Libraries/CMSIS/Device/Source/arm/: startup_stm32f103xe.s
  group CMSIS
    ./Libraries/CMSIS/Device/Source/: system_stm32f1xx.c
  group FreeRTOS/Source
    ./FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/Port
    ./FreeRTOS/Port/GCC/ARM_CM3/: port.c
    ./FreeRTOS/Port/MemMang/: heap_4.c
  group HAL
    ./HAL/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_timebase_rtc_alarm.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_adc.c stm32f1xx_ll_crc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_usb.c stm32f1xx_ll_utils.c
  group User
    ./User/: main.c FreeRTOSConfig.h stm32f1xx_hal_conf.h task_functions.c stm32f1xx_it.c GB2312_Font.c
    ./User/whx_libraries/source/: whx_peripherals.c whx_interrupts.c whx_communicate_usart.c whx_communicate_i2c.c whx_communicate_spi.c whx_on_chip.c
